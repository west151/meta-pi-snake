PACKAGECONFIG_append = " accessibility eglfs fontconfig gles2 linuxfb tslib opengl"
PACKAGECONFIG_remove = "examples tests"

DEPENDS += "userland"
